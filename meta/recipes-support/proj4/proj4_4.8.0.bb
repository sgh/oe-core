require proj4.inc

DEPENDS += "proj4-native"

SRC_URI[md5sum] = "d815838c92a29179298c126effbb1537"
SRC_URI[sha256sum] = "2db2dbf0fece8d9880679154e0d6d1ce7c694dd8e08b4d091028093d87a9d1b5"
